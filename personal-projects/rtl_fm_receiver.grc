options:
  parameters:
    author: jkaminski
    generate_options: qt_gui
    id: rtl_fm_receiver
    output_language: python
    title: Communications Theory FM Receiver Demo
  states: {}

blocks:
- name: Channel
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '88.3'
    step: '0.2'
    stop: '106.9'
    value: '99.5'
  states: {}
- name: Gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: Volume
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '15'
    value: '3'
  states: {}
- name: b
  id: variable
  parameters:
    value: '[0.5, 0, -0.5]'
  states: {}
- name: flo
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: input_idx
  id: variable
  parameters:
    value: 1 if use_envelope == False else 0
  states: {}
- name: output_idx
  id: variable
  parameters:
    value: 1 if use_envelope == False else 0
  states: {}
- name: rtl_freq
  id: variable
  parameters:
    value: Channel if use_envelope == False else Channel + flo
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 228e3
  states: {}
- name: use_envelope
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/5)
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/5)
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: output_idx
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: input_idx
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: (-1, 1)
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: '1'
    gain: '1'
    samp_rate: 'samp_rate '
    type: fir_filter_fff
    width: '5000'
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'This is a Demo for Dr. Weitzen''s Communications Theory Class. There are two options for demodulation: The envelope detector or the PLL. Use the check box to select which option, and notice the difference in audio quality. '
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate / 5
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.00001'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.00001'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: rtl_freq * 1e6
    gain0: Gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_complex_to_real_0, '0', fir_filter_xxx_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_selector_0_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_selector_0, '0', dc_blocker_xx_0, '0']
- [blocks_selector_0, '1', low_pass_filter_0, '0']
- [blocks_selector_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_xx_0, '0']
- [dc_blocker_xx_0, '0', blocks_complex_to_real_0, '0']
- [fir_filter_xxx_0, '0', blocks_delay_0, '0']
- [fir_filter_xxx_0, '0', blocks_threshold_ff_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_selector_0_0, '1']
- [rtlsdr_source_0, '0', blocks_selector_0, '0']

metadata:
  file_format: 1
