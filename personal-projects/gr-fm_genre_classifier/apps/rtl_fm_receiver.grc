options:
  parameters:
    author: jkaminski
    generate_options: qt_gui
    id: rtl_fm_receiver
    output_language: python
    title: Communications Theory FM Receiver Demo
  states: {}

blocks:
- name: Channel
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '88.3'
    step: '0.2'
    stop: '106.9'
    value: '101.1'
  states: {}
- name: Gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: Volume
  id: variable_qtgui_range
  parameters:
    label: Volume (Only for Envelope Detector)
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '50'
    value: '25'
    widget: dial
  states: {}
- name: flo
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rtl_freq
  id: variable
  parameters:
    value: Channel +flo
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 240e3
  states: {}
- name: segment_len_samples
  id: variable
  parameters:
    value: segment_len_seconds*samp_rate/10
  states: {}
- name: segment_len_seconds
  id: variable
  parameters:
    value: '30'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/10)
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(segment_len_samples)
    type: float
  states: {}
- name: fm_genre_classifier_classify_genre_0
  id: fm_genre_classifier_classify_genre
  parameters:
    clf_file: /home/jkaminski/git-repos/sdr-projects/personal-projects/gr-fm_genre_classifier/apps/genre_clf.sav
    lda_file: /home/jkaminski/git-repos/sdr-projects/personal-projects/gr-fm_genre_classifier/apps/genre_lda.sav
    scaler_file: /home/jkaminski/git-repos/sdr-projects/personal-projects/gr-fm_genre_classifier/apps/genre_scaler.sav
    segment_len_samples: int(segment_len_samples)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: int(samp_rate/10)
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: int(int(samp_rate/10) * .2)
    srate: int(samp_rate/10)
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: rtl_freq * 1e6
    gain0: Gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', blocks_stream_to_vector_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', fm_genre_classifier_classify_genre_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
